# Keil uVision project prject.uvproj, settings and files
target STM32F103C8T6 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32for818 +hex
  c flags: Optim=2 OneElfS=1
  c include: ..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\uCOS-II\CPU;..\uCOS-II\Source;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ../Libraries/CMSIS/STM32F10x/startup/: startup_stm32f10x_md.s
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/STM32F10x/: system_stm32f10x.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c
  group USB-FS-Device_Driver
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Board_Driver
    ./src/: m3_sys.c uart.c retarget.c
  group User
    ./src/: main.c gpio.c tr.c adc.c tim.c hw_config.c user_config.c I2c_slave.c
  group USB
    ./src/: usb_pwr.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c
  group Interrupts
    ./src/: stm32f10x_it.c
